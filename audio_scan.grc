options:
  parameters:
    gen_cmake: 'Off'
    generate_options: qt_gui
    id: audio_scan
    output_language: python
    title: cbrs_Scan
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 88e6
    step: 200e3
    stop: 108e6
    value: 98.5e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '30'
    value: '15'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '20'
    quad_rate: samp_rate/20
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1000'
    interp: '441'
    taps: ''
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: center_freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
